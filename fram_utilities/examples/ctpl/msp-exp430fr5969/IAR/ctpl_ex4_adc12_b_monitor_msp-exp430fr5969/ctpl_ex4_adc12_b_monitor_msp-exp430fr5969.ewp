# IAR project ctpl_ex4_adc12_b_monitor_msp-exp430fr5969.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR5969 MSP430FR5969
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: CTPL_STACK_SIZE=160; CTPL_SAVE_TA0; CTPL_SAVE_REF_A; CTPL_SAVE_ADC12_B
  ICC430.newCCIncludePaths: ..\..\..\..\..\src\ctpl
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.ADefines: CTPL_STACK_SIZE=160; __LARGE_CODE_MODEL__
  XLINK.XclFile: ..\..\..\..\..\src\ctpl\devices\msp430fr5969\ctpl_lnk430fr5969.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ../../: ctpl_ex4_adc12_b_monitor_msp-exp430fr5969.c
    ../../../../../src/ctpl/devices/msp430fr5969/: ctpl_msp430fr5969.c
    ../../../../../src/ctpl/: ctpl_pre_init.c
  group fram-utilities/ctpl
    ../../../../../src/ctpl/: ctpl.c ctpl.h ctpl_benchmark.h ctpl_copy.h ctpl_low_level.h ctpl_low_level.s43 ctpl_low_level_macros.m43
  group fram-utilities/ctpl/peripherals
    ../../../../../src/ctpl/peripherals/: ctpl_hwreg.h ctpl_peripherals.h ctpl_adc.c ctpl_adc.h ctpl_adc10_b.c ctpl_adc10_b.h ctpl_adc12_b.c ctpl_adc12_b.h ctpl_captio.c ctpl_captio.h ctpl_comp_d.c ctpl_comp_d.h ctpl_comp_e.c ctpl_comp_e.h ctpl_crc16.c ctpl_crc16.h ctpl_crc32.c ctpl_crc32.h ctpl_cs.c ctpl_cs.h ctpl_dmax_3.c ctpl_dmax_3.h ctpl_dmax_6.c ctpl_dmax_6.h ctpl_ecomp.c ctpl_ecomp.h ctpl_eusci_a.c ctpl_eusci_a.h ctpl_eusci_b.c ctpl_eusci_b.h ctpl_fram.c ctpl_fram.h ctpl_lcd_c.c ctpl_lcd_c.h ctpl_lcd_e.c ctpl_lcd_e.h ctpl_mpu.c ctpl_mpu.h ctpl_mpy32.c ctpl_mpy32.h ctpl_pmm.c ctpl_pmm.h ctpl_port.c ctpl_port.h ctpl_port_int.c ctpl_port_int.h ctpl_rc.c ctpl_rc.h ctpl_ref_a.c ctpl_ref_a.h ctpl_rtc.c ctpl_rtc.h ctpl_rtc_b.c ctpl_rtc_b.h ctpl_rtc_c.c ctpl_rtc_c.h ctpl_sac.c ctpl_sac.h ctpl_sfr.c ctpl_sfr.h ctpl_sys.c ctpl_sys.h ctpl_timer_2.c ctpl_timer_2.h ctpl_timer_3.c ctpl_timer_3.h ctpl_timer_5.c ctpl_timer_5.h ctpl_timer_7.c ctpl_timer_7.h ctpl_tri.c ctpl_tri.h ctpl_wdt_a.c ctpl_wdt_a.h
