# IAR project nvs_ex1_odometer.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR5969 MSP430FR5969
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\..\..\..\src\nvs
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.ADefines: CTPL_STACK_SIZE=160; __LARGE_CODE_MODEL__
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430fr5969.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ../../: nvs_ex1_odometer.c
  group fram-utilities/nvs
    ../../../../src/nvs/: nvs.h nvs_data.c nvs_data.h nvs_log.c nvs_log.h nvs_ring.c nvs_ring.h nvs_support.c nvs_support.h
