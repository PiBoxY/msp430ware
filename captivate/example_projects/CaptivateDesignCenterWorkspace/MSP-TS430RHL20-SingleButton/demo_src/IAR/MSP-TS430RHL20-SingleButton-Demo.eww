<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
   <path>$WS_DIR$/MSP-TS430RHL20-SingleButton-Demo.ewp</path>
  </project>
  <batchBuild/>
</workspace>


