<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
   <path>$WS_DIR$/Backchannel_UART-Demo.ewp</path>
  </project>
  <batchBuild/>
</workspace>


