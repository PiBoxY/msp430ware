# IAR project MSP-EXP430F5529LP_KeypadHostDemo_USBNumPad.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: DEPRECATED
  ICC430.newCCIncludePaths: ../driverlib/MSP430F5xx_6xx; ..; ../USB_config
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5529.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG DEPRECATED
  ICC430.newCCIncludePaths: ../../../../..; ../../../../../driverlib/MSP430F5xx_6xx; ..; ../USB_config
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: board.c board.h keypad.c keypad.h main.c system_pre_init.c
  group driverlib
    ../driverlib/: APIS_REMOVED.html release_notes.html
  group driverlib/MSP430F5xx_6xx
    ../driverlib/MSP430F5xx_6xx/: adc10_a.c adc10_a.h adc12_a.c adc12_a.h aes.c aes.h battbak.c battbak.h comp_b.c comp_b.h crc.c crc.h ctsd16.c ctsd16.h dac12_a.c dac12_a.h dma.c dma.h driverlib.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h flashctl.c flashctl.h gpio.c gpio.h lcd_b.c lcd_b.h ldopwr.c ldopwr.h mpy32.c mpy32.h oa.c oa.h pmap.c pmap.h pmm.c pmm.h ram.c ram.h ref.c ref.h rtc_a.c rtc_a.h rtc_b.c rtc_b.h rtc_c.c rtc_c.h sd24_b.c sd24_b.h sfr.c sfr.h sysctl.c sysctl.h tec.c tec.h timer_a.c timer_a.h timer_b.c timer_b.h timer_d.c timer_d.h tlv.c tlv.h ucs.c ucs.h usci_a_spi.c usci_a_spi.h usci_a_uart.c usci_a_uart.h usci_b_i2c.c usci_b_i2c.h usci_b_spi.c usci_b_spi.h wdt_a.c wdt_a.h
  group driverlib/MSP430F5xx_6xx/inc
    ../driverlib/MSP430F5xx_6xx/inc/: hw_memmap.h version.h
  group USB_API
    ../USB_API/: msp430USB.ld
  group USB_API/USB_CDC_API
    ../USB_API/USB_CDC_API/: UsbCdc.c UsbCdc.h
  group USB_API/USB_Common
    ../USB_API/USB_Common/: defMSP430USB.h device.h types.h usb.c usb.h usbdma.c UsbIsr.h
  group USB_API/USB_HID_API
    ../USB_API/USB_HID_API/: UsbHid.c UsbHid.h UsbHidReq.c UsbHidReq.h
  group USB_API/USB_MSC_API
    ../USB_API/USB_MSC_API/: UsbMsc.h UsbMscReq.c UsbMscReq.h UsbMscScsi.c UsbMscScsi.h UsbMscStateMachine.c UsbMscStateMachine.h
  group USB_API/USB_PHDC_API
    ../USB_API/USB_PHDC_API/: UsbPHDC.c UsbPHDC.h
  group USB_app
    ../USB_app/: keyboard.c keyboard.h usbEventHandling.c
  group USB_config
    ../USB_config/: descriptors.c descriptors.h H8_Keyboard.xml UsbIsr.c
