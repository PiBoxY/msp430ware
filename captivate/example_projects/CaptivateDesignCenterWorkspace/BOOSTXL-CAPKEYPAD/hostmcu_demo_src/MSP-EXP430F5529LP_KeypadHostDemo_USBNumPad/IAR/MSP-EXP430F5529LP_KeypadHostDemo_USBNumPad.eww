<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MSP-EXP430F5529LP_KeypadHostDemo_USBNumPad.ewp</path>
    </project>
    <batchBuild />
</workspace>
