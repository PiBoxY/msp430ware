<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MSP-EXP430FR6989_KeypadHostDemo_SEGLCD.ewp</path>
  </project>
  <batchBuild/>
</workspace>


