<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <CDC_IAR_EWW_EWP_PATH>
  </project>
  <batchBuild/>
</workspace>


