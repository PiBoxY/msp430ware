<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\vector_ex1_max_q15\vector_ex1_max_q15.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\vector_ex2_complex_add_q15\vector_ex2_complex_add_q15.ewp</path>
  </project>
  <batchBuild/>
</workspace>


