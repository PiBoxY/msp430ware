<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <EMDC_IAR_EWW_EWP_PATH>
  </project>
  <batchBuild/>
</workspace>


