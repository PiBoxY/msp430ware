# IAR project MSP430F522x_I2C.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F5229 MSP430F5229
  General.GStackSize2: 400
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..\API; ..\Command_Interpreter; ..\Peripheral_Interfaces
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: CONFIG\lnk430_BSL_AREA_RAM_2400-33FF.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.ADefines: NDEBUG
  group (top)
    ../API/: BSL430_API.c BSL430_API.h
    ../Command_Interpreter/: BSL430_Command_Definitions.h BSL430_Command_Interpreter.c BSL430_Command_Interpreter.h
    ./: BSL430_Low_Level_Init.s43 BSL_Device_File.h
    ../Peripheral_Interfaces/: BSL430_PI.h
    ../Peripheral_Interfaces/USCIB_I2C/: BSL430_PI_USCIB_I2C.c
