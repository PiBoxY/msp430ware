# IAR project G2xxx_MainApp_ASM.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430G2211 MSP430G2211
  General.GStackSize2: 0x40
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: lnk430G2211.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: mainApp_IAR.asm
