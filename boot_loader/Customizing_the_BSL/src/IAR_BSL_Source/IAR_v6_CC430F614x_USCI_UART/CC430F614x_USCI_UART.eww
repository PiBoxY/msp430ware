<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CC430F614x_USCI_UART.ewp</path>
  </project>
  <batchBuild/>
</workspace>


