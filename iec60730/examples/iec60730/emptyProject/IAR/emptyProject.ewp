# IAR project emptyProject.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5503 MSP430F5503
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: $PROJ_DIR$../../../../../iec60730/include
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.AUserIncludes: $PROJ_DIR$../../../../../iec60730/include
  XLINK.XclFile: .xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F5510 MSP430F5510
  ICC430.CCDefines: NDEBUG
  ICC430.newCCIncludePaths: ..\..\..\..\iec60730\include
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  A430.AUserIncludes: ..\..\..\..\iec60730\include
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: main.c
  group IEC60730/include
    ../../../../iec60730/include/: IEC60730_adc_test.h IEC60730_clock_fail_test.h IEC60730_cpu_test.h IEC60730_crc_test.h IEC60730_gpio_test.h IEC60730_march_test.h IEC60730_pc_test.h IEC60730_system_config.h IEC60730_user_config.h
  group IEC60730/source
    ../../../../iec60730/source/: IEC60730_adc_test.c IEC60730_clock_fail_test.c IEC60730_cpu_test_IAR.s43 IEC60730_crc_test.c IEC60730_gpio_test.c IEC60730_march_test.c IEC60730_pc_test.c
