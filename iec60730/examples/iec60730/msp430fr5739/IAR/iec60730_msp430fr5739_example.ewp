# IAR project iec60730_msp430fr5739_example.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FR5739 MSP430FR5739
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\..\..\..\iec60730\include; ..\..\..\..\driverlib\MSP430FR57xx
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.AUserIncludes: ..\..\..\..\iec60730\include
  XLINK.XclFile: lnk430fr5739.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk430fr5739.xcl
  group (top)
    ./: lnk430fr5739.xcl
    ../: main.c
  group driverlib
    ../../../../driverlib/MSP430FR57xx/: adc10_b.c adc10_b.h comp_d.c comp_d.h crc.c crc.h cs.c cs.h dma.c dma.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h framctl.c framctl.h gpio.c gpio.h mpu.c mpu.h mpy32.c mpy32.h pmm.c pmm.h ref.c ref.h driverlib.h rtc_b.c rtc_b.h sfr.c sfr.h sysctl.c sysctl.h timer_a.c timer_a.h timer_b.c timer_b.h tlv.c tlv.h wdt_a.c wdt_a.h
  group driverlib/deprecated/IAR
    ../../../../driverlib/MSP430FR57xx/deprecated/IAR/: msp430xgeneric.h
  group driverlib/inc
    ../../../../driverlib/MSP430FR57xx/inc/: hw_memmap.h hw_regaccess.h hw_types.h
  group IEC60730
    ../../../../iec60730/source/: IEC60730_adc_test.c IEC60730_clock_fail_test.c IEC60730_cpu_test_IAR.s43 IEC60730_crc_test.c IEC60730_gpio_test.c IEC60730_march_test.c IEC60730_pc_test.c
