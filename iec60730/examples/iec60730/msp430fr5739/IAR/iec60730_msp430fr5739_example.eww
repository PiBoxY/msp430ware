<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\iec60730_msp430fr5739_example.ewp</path>
  </project>
  <batchBuild/>
</workspace>


