# IAR project OutOfBox_MSP-EXP430FR2355.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllfn.h
  General.OGChipSelectMenu: MSP430FR2355 MSP430FR2355
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\driverlib\MSP430FR2xx_4xx; ..\jsmn
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430fr2355.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ../: functiongenerator.c functiongenerator.h lightsensor.c lightsensor.h main.c
    $EW_DIR$/430/lib/MathLib/: MSPMATHLIB_IAR_msp430_CPUX_large_code_large_data.lib
  group driverlib/MSP430FR2xx_4xx
    ../driverlib/MSP430FR2xx_4xx/: adc.c adc.h crc.c crc.h cs.c cs.h driverlib.h ecomp.c ecomp.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h framctl.c framctl.h gpio.c gpio.h icc.c icc.h lcd_e.c lcd_e.h mpy32.c mpy32.h pmm.c pmm.h rom_driverlib.h rom_map_driverlib.h rtc.c rtc.h sac.c sac.h sfr.c sfr.h sysctl.c sysctl.h tia.c tia.h timer_a.c timer_a.h timer_b.c timer_b.h tlv.c tlv.h wdt_a.c wdt_a.h
  group driverlib/MSP430FR2xx_4xx/inc
    ../driverlib/MSP430FR2xx_4xx/inc/: hw_memmap.h version.h
  group driverlib/MSP430FR2xx_4xx/rom_headers
    ../driverlib/MSP430FR2xx_4xx/rom_headers/: rom_driverlib_fr235x.h rom_driverlib_fr253x_fr263x.h
  group jsmn
    ../jsmn/: jsmn.c jsmn.h
