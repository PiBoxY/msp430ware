# IAR project BlinkLED_MSP430FR2433.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR2433 MSP430FR2433
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..\driverlib\MSP430FR2xx_4xx
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  group (top)
    ../: main.c
  group driverlib
    ../driverlib/: manifest.html release_notes.html
  group driverlib/MSP430FR2xx_4xx
    ../driverlib/MSP430FR2xx_4xx/: adc.c adc.h crc.c crc.h cs.c cs.h driverlib.h ecomp.c ecomp.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h framctl.c framctl.h gpio.c gpio.h lcd_e.c lcd_e.h mpy32.c mpy32.h pmm.c pmm.h rtc.c rtc.h sac.c sac.h sfr.c sfr.h sysctl.c sysctl.h tia.c tia.h timer_a.c timer_a.h timer_b.c timer_b.h tlv.c tlv.h wdt_a.c wdt_a.h
  group driverlib/MSP430FR2xx_4xx/inc
    ../driverlib/MSP430FR2xx_4xx/inc/: hw_memmap.h version.h
  group driverlib/MSP430FR2xx_4xx/rom_headers
    ../driverlib/MSP430FR2xx_4xx/rom_headers/: rom_driverlib_fr253x_fr263x.h
