# IAR project OutOfBox_MSP430FR2433.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xssfn.h
  General.OGChipSelectMenu: MSP430FR2433 MSP430FR2433
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: CTPL_STACK_SIZE=160
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..\jsmn; ..\iqmathlib\include; ..\fram-utilities\ctpl; ..\fram-utilities\nvs; ..\driverlib\MSP430FR2xx_4xx
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  A430.ADefines: CTPL_STACK_SIZE=160
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430fr2433.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptStrategy: 0
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ../: ctpl_msp430fr2433.c ctpl_pre_init.c FRAMLogMode.c FRAMLogMode.h LiveTempMode.c LiveTempMode.h main.c
  group driverlib
    ../driverlib/: manifest.html release_notes.html
  group driverlib/MSP430FR2xx_4xx
    ../driverlib/MSP430FR2xx_4xx/: adc.c adc.h crc.c crc.h cs.c cs.h driverlib.h ecomp.c ecomp.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h framctl.c framctl.h gpio.c gpio.h lcd_e.c lcd_e.h mpy32.c mpy32.h pmm.c pmm.h rtc.c rtc.h sac.c sac.h sfr.c sfr.h sysctl.c sysctl.h tia.c tia.h timer_a.c timer_a.h timer_b.c timer_b.h tlv.c tlv.h wdt_a.c wdt_a.h
  group driverlib/MSP430FR2xx_4xx/inc
    ../driverlib/MSP430FR2xx_4xx/inc/: hw_memmap.h version.h
  group driverlib/MSP430FR2xx_4xx/rom_headers
    ../driverlib/MSP430FR2xx_4xx/rom_headers/: rom_driverlib_fr253x_fr263x.h
  group fram-utilities/ctpl
    ../fram-utilities/ctpl/: ctpl.c ctpl.h ctpl_benchmark.h ctpl_copy.h ctpl_low_level.h ctpl_low_level.s43 ctpl_low_level_macros.m43
  group fram-utilities/ctpl/peripherals
    ../fram-utilities/ctpl/peripherals/: ctpl_adc.c ctpl_adc.h ctpl_adc10_b.c ctpl_adc10_b.h ctpl_adc12_b.c ctpl_adc12_b.h ctpl_captio.c ctpl_captio.h ctpl_comp_d.c ctpl_comp_d.h ctpl_comp_e.c ctpl_comp_e.h ctpl_crc16.c ctpl_crc16.h ctpl_crc32.c ctpl_crc32.h ctpl_cs.c ctpl_cs.h ctpl_dmax_3.c ctpl_dmax_3.h ctpl_dmax_6.c ctpl_dmax_6.h ctpl_ecomp.c ctpl_ecomp.h ctpl_eusci_a.c ctpl_eusci_a.h ctpl_eusci_b.c ctpl_eusci_b.h ctpl_fram.c ctpl_fram.h ctpl_hwreg.h ctpl_lcd_c.c ctpl_lcd_c.h ctpl_lcd_e.c ctpl_lcd_e.h ctpl_mpu.c ctpl_mpu.h ctpl_mpy32.c ctpl_mpy32.h ctpl_peripherals.h ctpl_pmm.c ctpl_pmm.h ctpl_port.c ctpl_port.h ctpl_port_int.c ctpl_port_int.h ctpl_rc.c ctpl_rc.h ctpl_ref_a.c ctpl_ref_a.h ctpl_rtc.c ctpl_rtc.h ctpl_rtc_b.c ctpl_rtc_b.h ctpl_rtc_c.c ctpl_rtc_c.h ctpl_sac.c ctpl_sac.h ctpl_sfr.c ctpl_sfr.h ctpl_sys.c ctpl_sys.h ctpl_timer_2.c ctpl_timer_2.h ctpl_timer_3.c ctpl_timer_3.h ctpl_timer_5.c ctpl_timer_5.h ctpl_timer_7.c ctpl_timer_7.h ctpl_tri.c ctpl_tri.h ctpl_wdt_a.c ctpl_wdt_a.h
  group fram-utilities/nvs
    ../fram-utilities/nvs/: nvs.h nvs_data.c nvs_data.h nvs_log.c nvs_log.h nvs_ring.c nvs_ring.h nvs_support.c nvs_support.h
  group iqmathlib/include
    ../iqmathlib/include/: IQmathLib.h QmathLib.h
  group iqmathlib/libraries/IAR/MPY32/5xx_6xx
    ../iqmathlib/libraries/IAR/MPY32/5xx_6xx/: QmathLib_IAR_MPY32_5xx_6xx_CPUX_small_code_small_data.lib
  group jsmn
    ../jsmn/: jsmn.c jsmn.h
