# IAR project MSP-EXP430F6137Rx User Experience.ewp, settings and files
configuration US_915MHz (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: CC430F6137 CC430F6137
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: __CC430F6137__; ISM_US; MRFI_CC430
  ICC430.IExtraOptions: -f"..\SimpliciTI\Application\configuration\Access_Point\smpl_config_IAR.dat"; -f"..\SimpliciTI\Application\configuration\smpl_nwk_config_IAR.dat"
  ICC430.newCCIncludePaths: ..\MSP-EXP430F6137_HAL; ..\F5xx_F6xx_Core_Lib; ..\SimpliciTI\Components\bsp; ..\SimpliciTI\Components\bsp\drivers; ..\SimpliciTI\Components\bsp\boards\MSP-EXP430F6137Rx; ..\SimpliciTI\Components\mrfi; ..\SimpliciTI\Components\simpliciti\nwk; ..\SimpliciTI\Components\simpliciti\nwk_applications
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkCC430F6137.xcl
  XLINK.XlinkStackSize: 1
configuration EU_868MHz (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: __CC430F6137__; ISM_EU; MRFI_CC430
configuration LF_433MHz (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: __CC430F6137__; ISM_LF; MRFI_CC430
  group (top)
    ../: main.c MspExp430F6137RxUserExperience.c readme.txt
  group F5xx_F6xx_Core_Lib
    ../F5xx_F6xx_Core_Lib/: HAL_FLASH.c HAL_FLASH.h hal_macros.h HAL_PMAP.c HAL_PMAP.h HAL_PMM.c HAL_PMM.h HAL_TLV.c HAL_TLV.h HAL_UCS.c HAL_UCS.h
  group MSP-EXP430F6137_HAL
    ../MSP-EXP430F6137_HAL/: hal_adc.c hal_adc.h hal_buttons.c hal_buttons.h hal_lcd.c hal_lcd.h hal_leds.c hal_leds.h hal_msp-exp430f6137rx.h hal_uart.c hal_uart.h RF1A.c RF1A.h
  group SimpliciTI/Application/configuration
    ../SimpliciTI/Application/configuration/: smpl_nwk_config_IAR.dat
  group SimpliciTI/Application/configuration/Access_Point
    ../SimpliciTI/Application/configuration/Access_Point/: smpl_config_IAR.dat
  group SimpliciTI/Components/bsp
    ../SimpliciTI/Components/bsp/: bsp.c bsp.h bsp_macros.h
  group SimpliciTI/Components/bsp/boards/MSP-EXP430F6137Rx
    ../SimpliciTI/Components/bsp/boards/MSP-EXP430F6137Rx/: bsp_board.c bsp_board_defs.h bsp_button_defs.h bsp_config.h bsp_driver_defs.h bsp_drivers.c bsp_led_defs.h
  group SimpliciTI/Components/bsp/boards/MSP-EXP430F6137Rx/bsp_external
    ../SimpliciTI/Components/bsp/boards/MSP-EXP430F6137Rx/bsp_external/: mrfi_board_defs.h
  group SimpliciTI/Components/bsp/boards/MSP-EXP430F6137Rx/schematics
    ../SimpliciTI/Components/bsp/boards/MSP-EXP430F6137Rx/schematics/: ReplaceWithRealSchematic.pdf
  group SimpliciTI/Components/bsp/drivers
    ../SimpliciTI/Components/bsp/drivers/: bsp_buttons.h bsp_leds.h
  group SimpliciTI/Components/bsp/drivers/code
    ../SimpliciTI/Components/bsp/drivers/code/: bsp_buttons.c bsp_generic_buttons.h bsp_generic_leds.h bsp_leds.c
  group SimpliciTI/Components/bsp/mcus
    ../SimpliciTI/Components/bsp/mcus/: bsp_msp430_defs.h
  group SimpliciTI/Components/mrfi
    ../SimpliciTI/Components/mrfi/: mrfi.c mrfi.h mrfi_defs.h
  group SimpliciTI/Components/mrfi/radios/family5
    ../SimpliciTI/Components/mrfi/radios/family5/: mrfi_radio.c mrfi_radio_interface.c mrfi_radio_interface.h
  group SimpliciTI/Components/mrfi/radios/smartrf/CC430
    ../SimpliciTI/Components/mrfi/smartrf/CC430/: rfstudio.srfsCC430Fx13x smartrf_CC430.h
  group SimpliciTI/Components/simpliciti/nwk
    ../SimpliciTI/Components/simpliciti/nwk/: nwk.c nwk.h nwk_api.c nwk_api.h nwk_app.h nwk_frame.c nwk_frame.h nwk_globals.c nwk_globals.h nwk_QMgmt.c nwk_QMgmt.h nwk_types.h
  group SimpliciTI/Components/simpliciti/nwk_applications
    ../SimpliciTI/Components/simpliciti/nwk_applications/: nwk_freq.c nwk_freq.h nwk_ioctl.c nwk_ioctl.h nwk_join.c nwk_join.h nwk_link.c nwk_link.h nwk_mgmt.c nwk_mgmt.h nwk_ping.c nwk_ping.h nwk_security.c nwk_security.h
