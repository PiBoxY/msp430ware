<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\BOOSTXL-SHARP128_GrlibExample_FR5969.ewp</path>
    </project>
    <batchBuild />
</workspace>
