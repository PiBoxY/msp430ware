<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\430BOOST-SHARP96_ULP_FRAM.ewp</path>
  </project>
  <batchBuild/>
</workspace>


