# IAR project 430BOOST-SHARP96_ULP_FRAM.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR5969 MSP430FR5969
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ../; ../driverlib/MSP430FR5xx_6xx; ../GrLib/fonts; ../GrLib/grlib; ../LcdDriver
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk430fr5969.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: ActivePowerMeasure.c ActivePowerMeasure.h ClockApp.c ClockApp.h FR59xx_EXP.c FR59xx_EXP.h FRAMSpeedApp.c FRAMSpeedApp.h Game.c Game.h msp430fr59xx_CHR.h msp430fr59xx_CHR.s43 myTimer.c myTimer.h ULPMeter.c ULPMeter.h UpdateDisplay.c UpdateDisplay.h
    ./: low_level_init.c
  group CTS
    ../CTS/: CTS_HAL.c CTS_HAL.h CTS_Layer.c CTS_Layer.h CTS_wolverine.c CTS_wolverine.h structure.c structure.h
  group driverlib/MSP430FR5xx_6xx
    ../driverlib/MSP430FR5xx_6xx/: adc12_b.c adc12_b.h aes256.c aes256.h comp_e.c comp_e.h crc.c crc.h crc32.c crc32.h cs.c cs.h dma.c dma.h driverlib.h esi.c esi.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h framctl.c framctl.h gpio.c gpio.h lcd_c.c lcd_c.h mpu.c mpu.h mpy32.c mpy32.h pmm.c pmm.h ram.c ram.h ref_a.c ref_a.h rtc_b.c rtc_b.h rtc_c.c rtc_c.h sfr.c sfr.h sysctl.c sysctl.h timer_a.c timer_a.h timer_b.c timer_b.h tlv.c tlv.h wdt_a.c wdt_a.h
  group driverlib/MSP430FR5xx_6xx/deprecated/CCS
    ../driverlib/MSP430FR5xx_6xx/deprecated/CCS/: msp430fr5xx_6xxgeneric.h
  group driverlib/MSP430FR5xx_6xx/deprecated/IAR
    ../driverlib/MSP430FR5xx_6xx/deprecated/IAR/: msp430fr5xx_6xxgeneric.h
  group driverlib/MSP430FR5xx_6xx/inc
    ../driverlib/MSP430FR5xx_6xx/inc/: hw_memmap.h hw_regaccess.h hw_types.h version.h
  group GrLib/fonts
    ../GrLib/fonts/: fontcm12.c fontcm12b.c fontcm12i.c fontcm14.c fontcm14b.c fontcm14i.c fontcm16.c fontcm16b.c fontcm16i.c fontcm18.c fontcm18b.c fontcm18i.c fontcm20.c fontcm20b.c fontcm20i.c fontcm22.c fontcm22b.c fontcm22i.c fontcm24.c fontcm24b.c fontcm24i.c fontcm26.c fontcm26b.c fontcm26i.c fontcm28.c fontcm28b.c fontcm28i.c fontcm30.c fontcm30b.c fontcm30i.c fontcm32.c fontcm32b.c fontcm32i.c fontcm34.c fontcm34b.c fontcm34i.c fontcm36.c fontcm36b.c fontcm36i.c fontcm38.c fontcm38b.c fontcm38i.c fontcm40.c fontcm40b.c fontcm40i.c fontcm42.c fontcm42b.c fontcm42i.c fontcm44.c fontcm44b.c fontcm44i.c fontcm46.c fontcm46b.c fontcm46i.c fontcm48.c fontcm48b.c fontcm48i.c fontcmsc12.c fontcmsc14.c fontcmsc16.c fontcmsc18.c fontcmsc20.c fontcmsc22.c fontcmsc24.c fontcmsc26.c fontcmsc28.c fontcmsc30.c fontcmsc32.c fontcmsc34.c fontcmsc36.c fontcmsc38.c fontcmsc40.c fontcmsc42.c fontcmsc44.c fontcmsc46.c fontcmsc48.c fontcmss12.c fontcmss12b.c fontcmss12i.c fontcmss14.c fontcmss14b.c fontcmss14i.c fontcmss16.c fontcmss16b.c fontcmss16i.c fontcmss18.c fontcmss18b.c fontcmss18i.c fontcmss20.c fontcmss20b.c fontcmss20i.c fontcmss22.c fontcmss22b.c fontcmss22i.c fontcmss24.c fontcmss24b.c fontcmss24i.c fontcmss26.c fontcmss26b.c fontcmss26i.c fontcmss28.c fontcmss28b.c fontcmss28i.c fontcmss30.c fontcmss30b.c fontcmss30i.c fontcmss32.c fontcmss32b.c fontcmss32i.c fontcmss34.c fontcmss34b.c fontcmss34i.c fontcmss36.c fontcmss36b.c fontcmss36i.c fontcmss38.c fontcmss38b.c fontcmss38i.c fontcmss40.c fontcmss40b.c fontcmss40i.c fontcmss42.c fontcmss42b.c fontcmss42i.c fontcmss44.c fontcmss44b.c fontcmss44i.c fontcmss46.c fontcmss46b.c fontcmss46i.c fontcmss48.c fontcmss48b.c fontcmss48i.c fontcmtt12.c fontcmtt14.c fontcmtt16.c fontcmtt18.c fontcmtt20.c fontcmtt22.c fontcmtt24.c fontcmtt26.c fontcmtt28.c fontcmtt30.c fontcmtt32.c fontcmtt34.c fontcmtt36.c fontcmtt38.c fontcmtt40.c fontcmtt42.c fontcmtt44.c fontcmtt46.c fontcmtt48.c fontfixed6x8.c
  group GrLib/grlib
    ../GrLib/grlib/: button.c button.h checkbox.c checkbox.h circle.c context.c display.c grlib.h image.c imageButton.c imageButton.h line.c radioButton.c radioButton.h rectangle.c string.c
  group LcdDriver
    ../LcdDriver/: HAL_MSP_EXP430FR5969_Sharp96x96.c HAL_MSP_EXP430FR5969_Sharp96x96.h Sharp96x96.c Sharp96x96.h
  group Preloaded_Images
    ../Preloaded_Images/: TI_logo.h Wolverine_slash.h
