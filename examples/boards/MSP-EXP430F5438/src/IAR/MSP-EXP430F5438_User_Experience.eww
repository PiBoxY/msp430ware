<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MSP-EXP430F5438_User_Experience.ewp</path>
  </project>
  <batchBuild/>
</workspace>


