# IAR project MSP-EXP430F5438_User_Experience.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\F5xx_F6xx_Core_Lib; ..\MSP-EXP430F5438_HAL; ..\UserExperienceDemo
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk430F5438A_mod.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: lnk430F5438A_mod.xcl low_level_init.c
    ../: main.c readme.txt
  group F5xx_F6xx_Core_Lib
    ../F5xx_F6xx_Core_Lib/: HAL_FLASH.c HAL_FLASH.h HAL_MACROS.h HAL_PMAP.c HAL_PMAP.h HAL_PMM.c HAL_PMM.h HAL_TLV.c HAL_TLV.h HAL_UCS.c HAL_UCS.h
  group MSP-EXP430F5438_HAL
    ../MSP-EXP430F5438_HAL/: cc2500.h hal_adc.c hal_adc.h hal_board.c hal_board.h hal_buttons.c hal_buttons.h hal_lcd.c hal_lcd.h hal_lcd_fonts.c hal_lcd_fonts.h hal_MSP-EXP430F5438.h hal_rf.c hal_rf.h hal_rf_settings.h hal_rtc.c hal_rtc.h hal_usb.c hal_usb.h
  group UserExperienceDemo
    ../UserExperienceDemo/: 5xx_ACTIVE_test.h 5xx_ACTIVE_test.s43 adcTemp.c adcTemp.h audio.c audio.h balanceBall.c balanceBall.h clock.c clock.h FFT.c FFT.h FFT_430.h FFT_430.s43 flashUtils.c flashUtils.h LPM.c LPM.h menuSetting.c menuSetting.h PMM.c PMM.h PowerTest.c PowerTest.h usbTest.c usbTest.h UserExperience_F5438A.c UserExperience_F5438A.h UserExperienceGraphics.c UserExperienceGraphics.h
