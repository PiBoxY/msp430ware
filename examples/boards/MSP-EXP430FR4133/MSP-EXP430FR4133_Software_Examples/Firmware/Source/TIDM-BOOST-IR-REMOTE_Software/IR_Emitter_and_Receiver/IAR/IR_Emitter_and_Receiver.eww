<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\IR_Emitter_and_Receiver.ewp</path>
  </project>
  <batchBuild/>
</workspace>


