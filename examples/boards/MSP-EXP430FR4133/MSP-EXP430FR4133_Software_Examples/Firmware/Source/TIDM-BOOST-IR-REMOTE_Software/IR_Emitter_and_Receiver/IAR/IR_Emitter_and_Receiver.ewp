# IAR project IR_Emitter_and_Receiver.ewp, settings and files
configuration IR_Emitter (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR4133 MSP430FR4133
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430FR4133.xcl
  XLINK.XlinkStackSize: 1
configuration IR_Receiver (MSP430, debug)
  as the first configuration, except:
  group (top)
    ./: FR4133_IR_BP_RX.c FR4133_IR_BP_TX.c HAL_FR4133LP_Board.c HAL_FR4133LP_Board.h HAL_FR4133LP_LCD.c HAL_FR4133LP_LCD.h
