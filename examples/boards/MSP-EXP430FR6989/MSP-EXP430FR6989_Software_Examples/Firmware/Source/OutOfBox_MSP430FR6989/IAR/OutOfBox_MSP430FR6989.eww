<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\OutOfBox_MSP430FR6989.ewp</path>
  </project>
  <batchBuild/>
</workspace>


