# IAR project 430BOOST-SHARP96_GrlibExample_G2.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\; ..\grlib\; ..\fonts\; ..\LcdDriver\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkCC430F5123.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: main.c
  group fonts
    ../fonts/: fontfixed6x8.c
  group grlib
    ../grlib/: circle.c context.c grlib.h image.c line.c rectangle.c string.c
  group LcdDriver
    ../LcdDriver/: Sharp96x96.c Sharp96x96.h HAL_MSP-EXP430G2_Sharp96x96.c HAL_MSP-EXP430G2_Sharp96x96.h
