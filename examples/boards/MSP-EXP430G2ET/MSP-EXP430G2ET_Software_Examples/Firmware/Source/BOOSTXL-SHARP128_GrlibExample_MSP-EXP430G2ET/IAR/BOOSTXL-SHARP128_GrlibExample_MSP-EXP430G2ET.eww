<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\BOOSTXL-SHARP128_GrlibExample_MSP-EXP430G2ET.ewp</path>
    </project>
    <batchBuild />
</workspace>
