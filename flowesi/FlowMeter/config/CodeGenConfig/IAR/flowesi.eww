<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
<FMCG_IAR_EWW_PROJ_PATH> 
  </project>
  <batchBuild/>
</workspace>


