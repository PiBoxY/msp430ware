# IAR project FR6047_USSSWLib_template_example.ewp, settings and files
configuration SINGLE_TONE (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xslfn.h
  General.OGChipSelectMenu: MSP430FR6047 MSP430FR6047
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: USS_PULSE_MODE=0
  ICC430.newCCIncludePaths: ..; ..\USS_Config; ..\..\..\include; ..\..\..\lib\USS\source; ..\..\..\lib\USS\source\USS_HAL
  ICC430.CCOptLevel: 2
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk430fr6047.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    ./: lnk430fr6047.xcl
    ../: main.c system_pre_init.c
  group IQMathLib
    ../../../include/: IQmathLib.h
    ../../../lib/IQMathLibrary/libraries/IAR/MPY32/5xx_6xx/: IQmathLib_IAR_MPY32_5xx_6xx_CPUX_small_code_large_data.lib
  group QMathLib
    ../../../include/: QmathLib.h
    ../../../lib/IQMathLibrary/libraries/IAR/MPY32/5xx_6xx/: QmathLib_IAR_MPY32_5xx_6xx_CPUX_small_code_large_data.lib
  group USS_Config
    ../USS_Config/: USS_userConfig.c USS_userConfig.h USSAbsTofLUT.h USSMeterVFRCalib.h
  group ussSWLib
    ../../../lib/USS/IAR/: USS_SW_IAR_small_code_large_data.lib
    ../../../include/: ussSwLib.h
  group ussSWLib/source
    ../../../lib/USS/source/: ussSwLibAppDebug.c ussSwLibCalibration.c ussSwLibCalibration.h ussSwLibConfiguration.c ussSwLibISR.c ussSwLibMeasurement.c
  group ussSWLib/source/common
    ../../../lib/USS/source/common/: benchmarkussswLib.c benchmarkussswLib.h USSGenericRegDef.h ussSwLibCommonHSPLL.c ussSwLibCommonHSPLL.h ussSwLibCommonInterrupts.c ussSwLibCommonInterrupts.h ussSwLibCommonSAPH.c ussSwLibCommonSAPH.h ussSwLibCommonSDHS.c ussSwLibCommonSDHS.h ussSwLibCommonTimer.c ussSwLibCommonTimer.h ussSwLibCommonUSS.c ussSwLibCommonUSS.h
  group ussSWLib/source/USS_HAL
    ../../../lib/USS/source/USS_HAL/: USS_Lib_HAL.c USS_Lib_HAL.h
