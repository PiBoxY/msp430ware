<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\FR6043_USSSWLib_template_example.ewp</path>
  </project>
  <batchBuild/>
</workspace>


