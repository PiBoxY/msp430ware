# IAR project FR6043_USSSWLib_template_example.ewp, settings and files
configuration SINGLE_TONE (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xslfn.h
  General.OGChipSelectMenu: MSP430FR6043 MSP430FR6043
  General.GStackSize2: 512
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: USS_PULSE_MODE=0; __EVM430_ID__=0x43; __EVM430_VER__=0x20; __AFE_EXT_3v3__
  ICC430.newCCIncludePaths: ..; ..\USS_Config; ..\..\..\include; ..\..\..\lib\USS\source\USS_HAL; ..\..\..\lib\USS\source\
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: lnk430fr6043.xcl
  XLINK.XlinkStackSize: 1
configuration MULTI_TONE (MSP430, debug)
  as the first configuration, except:
  General.GStackSize2: 160
  ICC430.CCDefines: USS_PULSE_MODE=2; __EVM430_ID__=0x43; __EVM430_VER__=0x20; __AFE_EXT_3v3__
  ICC430.newCCIncludePaths: ..; ..\USS_Config; ..\..\..\include; ..\..\..\\lib\USS\source; ..\..\..\lib\USS\source\USS_HAL
  ICC430.CCOptLevel: 3
  group (top)
    ./: lnk430fr6043.xcl
    ../: main.c system_pre_init.c
  group IQMathLib
    ../../../include/: IQmathLib.h
    ../../../lib/IQMathLibrary/libraries/IAR/MPY32/5xx_6xx/: IQmathLib_IAR_MPY32_5xx_6xx_CPUX_small_code_large_data.lib
  group QMathLib
    ../../../include/: QmathLib.h
    ../../../lib/IQMathLibrary/libraries/IAR/MPY32/5xx_6xx/: QmathLib_IAR_MPY32_5xx_6xx_CPUX_small_code_large_data.lib
  group USS_Config
    ../USS_Config/: USS_userConfig.c USS_userConfig.h USSAbsTofLUT.h USSMeterVFRCalib.h
  group ussSWLib
    ../../../lib/USS/IAR/: USS_SW_IAR_small_code_large_data.lib
    ../../../include/: ussSwLib.h
  group ussSWLib/source
    ../../../lib/USS/source/: ussSwLibAppDebug.c ussSwLibCalibration.c ussSwLibCalibration.h ussSwLibConfiguration.c ussSwLibISR.c ussSwLibMeasurement.c
  group ussSWLib/source/common
    ../../../lib/USS/source/common/: benchmarkussswLib.c benchmarkussswLib.h USSGenericRegDef.h ussSwLibCommonHSPLL.c ussSwLibCommonHSPLL.h ussSwLibCommonInterrupts.c ussSwLibCommonInterrupts.h ussSwLibCommonSAPH.c ussSwLibCommonSAPH.h ussSwLibCommonSDHS.c ussSwLibCommonSDHS.h ussSwLibCommonTimer.c ussSwLibCommonTimer.h ussSwLibCommonUSS.c ussSwLibCommonUSS.h
  group ussSWLib/source/USS_HAL
    ../../../lib/USS/source/USS_HAL/: USS_Lib_HAL.c USS_Lib_HAL.h
