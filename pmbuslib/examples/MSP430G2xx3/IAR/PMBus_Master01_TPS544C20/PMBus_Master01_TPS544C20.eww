<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\PMBus_Master01_TPS544C20.ewp</path>
  </project>
  <batchBuild/>
</workspace>


