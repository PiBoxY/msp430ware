# IAR project PMBus_Master02_TPS544C20_SMBAlert.ewp, settings and files
configuration MSP430G2553 (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MCLK_MHZ=8
  ICC430.newCCIncludePaths: ../../../../src/pmbuslib/; ../../../../smbuslib/src/smbuslib/; ../../../../smbuslib/src/smbuslib/MSP430G2xx3
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430G2553.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    ../../Src/PMBus_Master02_TPS544C20_SMBAlert/: main.c Master_HAL.c Master_HAL.h
  group pmbuslib
    ../../../../src/pmbuslib/: pmbus.c pmbus.h
  group smbuslib
    ../../../../smbuslib/src/smbuslib/: smbus.c smbus.h smbus_nwk.c smbus_nwk.h
  group smbuslib/MSP430FR5xx_6xx
    ../../../../smbuslib/src/smbuslib/MSP430FR5xx_6xx/: smbus_phy.c smbus_phy.h
  group smbuslib/MSP430G2xx3
    ../../../../smbuslib/src/smbuslib/MSP430G2xx3/: smbus_phy.c smbus_phy.h
