<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
      <path>$WS_DIR$\PMBus_Master02_TPS544C20_SMBAlert.ewp</path>
  </project>
  <batchBuild/>
</workspace>


