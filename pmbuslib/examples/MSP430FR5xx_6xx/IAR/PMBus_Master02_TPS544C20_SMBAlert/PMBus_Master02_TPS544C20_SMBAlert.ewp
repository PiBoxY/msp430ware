# IAR project PMBus_Master02_TPS544C20_SMBAlert.ewp, settings and files
configuration MSP430FR5969 (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR5969 MSP430FR5969
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MCLK_MHZ=8
  ICC430.newCCIncludePaths: ../../../../src/pmbuslib/; ../../../../smbuslib/driverlib/MSP430FR5xx_6xx; ../../../../smbuslib/src/smbuslib/; ../../../../smbuslib/src/smbuslib/MSP430FR5xx_6xx
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430FR5969.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    ../../Src/PMBus_Master02_TPS544C20_SMBAlert/: main.c Master_HAL.c Master_HAL.h
  group MSP430FR5xx_6xx
    ../../../../smbuslib/driverlib/MSP430FR5xx_6xx/: adc12_b.c adc12_b.h aes256.c aes256.h comp_e.c comp_e.h crc.c crc.h crc32.c crc32.h cs.c cs.h dma.c dma.h driverlib.h esi.c esi.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h framctl.c framctl.h gpio.c gpio.h lcd_c.c lcd_c.h mpu.c mpu.h mpy32.c mpy32.h pmm.c pmm.h ram.c ram.h ref_a.c ref_a.h rtc_b.c rtc_b.h rtc_c.c rtc_c.h sfr.c sfr.h sysctl.c sysctl.h timer_a.c timer_a.h timer_b.c timer_b.h tlv.c tlv.h wdt_a.c wdt_a.h
  group MSP430FR5xx_6xx/inc
    ../../../../smbuslib/driverlib/MSP430FR5xx_6xx/inc/: hw_memmap.h hw_regaccess.h hw_types.h version.h
  group pmbuslib
    ../../../../src/pmbuslib/: pmbus.c pmbus.h
  group smbuslib
    ../../../../smbuslib/src/smbuslib/: smbus.c smbus.h smbus_nwk.c smbus_nwk.h
  group smbuslib/MSP430FR5xx_6xx
    ../../../../smbuslib/src/smbuslib/MSP430FR5xx_6xx/: smbus_phy.c smbus_phy.h
  group smbuslib/MSP430G2xx3
    ../../../../smbuslib/src/smbuslib/MSP430G2xx3/: smbus_phy.c smbus_phy.h
