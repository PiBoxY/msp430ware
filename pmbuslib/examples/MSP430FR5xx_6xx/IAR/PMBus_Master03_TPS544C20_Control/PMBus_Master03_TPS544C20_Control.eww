<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\PMBus_Master03_TPS544C20_Control.ewp</path>
  </project>
  <batchBuild/>
</workspace>


