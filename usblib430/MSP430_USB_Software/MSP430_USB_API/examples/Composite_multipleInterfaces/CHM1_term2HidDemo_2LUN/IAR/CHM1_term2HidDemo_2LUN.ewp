# IAR project CHM1_term2HidDemo_2LUN.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: DEPRECATED
  ICC430.IExtraOptions: --diag_suppress Pe061
  ICC430.newCCIncludePaths: ../../../..; ../../../../driverlib/MSP430F5xx_6xx; ..; ../USB_config
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430F5529.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XExtraOptions: -P(CONST)MYDRIVE=0x10000-0x24400
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG DEPRECATED
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: hal.h system_pre_init.c hal.c main.h main.c
  group USB_config
    ../USB_config/: descriptors.h UsbIsr.c descriptors.c
  group USB_app
    ../USB_app/: usbConstructs.c LUN0_data.h LUN0_data.c LUN0.c LUN0.h usbConstructs.h LUN1.c usbEventHandling.c LUN1.h
  group USB_app/FatFs
    ../USB_app/FatFs/: mmc.h ff.h HAL_SDCard.c HAL_SDCard.h mmc.c ff.c ffconf.h diskio.h
  group USB_API
    ../../../../USB_API/: msp430USB.ld
  group USB_API/USB_PHDC_API
    ../../../../USB_API/USB_PHDC_API/: UsbPHDC.c UsbPHDC.h
  group USB_API/USB_HID_API
    ../../../../USB_API/USB_HID_API/: UsbHid.c UsbHidReq.c UsbHidReq.h UsbHid.h
  group USB_API/USB_CDC_API
    ../../../../USB_API/USB_CDC_API/: UsbCdc.c UsbCdc.h
  group USB_API/USB_Common
    ../../../../USB_API/USB_Common/: types.h usb.h device.h defMSP430USB.h usb.c usbdma.c UsbIsr.h
  group USB_API/USB_MSC_API
    ../../../../USB_API/USB_MSC_API/: UsbMscStateMachine.h UsbMscScsi.c UsbMscStateMachine.c UsbMscReq.h UsbMscReq.c UsbMscScsi.h UsbMsc.h
  group driverlib
    ../../../../driverlib/: APIS_REMOVED.html release_notes.html
  group driverlib/MSP430F5xx_6xx
    ../../../../driverlib/MSP430F5xx_6xx/: eusci_b_spi.h rtc_a.h driverlib.h dac12_a.c usci_b_spi.c pmap.h usci_b_i2c.c ctsd16.c oa.h rtc_a.c usci_a_spi.h sd24_b.h tec.c wdt_a.h rtc_c.h ucs.c ucs.h adc10_a.h ldopwr.c battbak.c comp_b.h lcd_b.h dac12_a.h flashctl.h mpy32.h ldopwr.h usci_b_i2c.h sd24_b.c gpio.c dma.c usci_a_uart.h wdt_a.c adc10_a.c eusci_a_uart.h pmm.c aes.h battbak.h usci_a_uart.c comp_b.c sysctl.c ctsd16.h mpy32.c tec.h rtc_b.h crc.h flashctl.c tlv.h oa.c lcd_b.c tlv.c eusci_a_uart.c aes.c dma.h sfr.h timer_b.h timer_a.c pmm.h sysctl.h rtc_c.c timer_b.c ram.c eusci_b_i2c.c adc12_a.h timer_d.h ref.c timer_d.c timer_a.h ref.h pmap.c eusci_a_spi.h eusci_b_spi.c usci_b_spi.h adc12_a.c rtc_b.c gpio.h eusci_a_spi.c usci_a_spi.c eusci_b_i2c.h sfr.c crc.c ram.h
  group driverlib/MSP430F5xx_6xx/inc
    ../../../../driverlib/MSP430F5xx_6xx/inc/: hw_memmap.h version.h
