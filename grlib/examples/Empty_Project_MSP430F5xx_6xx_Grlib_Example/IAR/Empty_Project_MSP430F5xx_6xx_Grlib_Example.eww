<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Empty_Project_MSP430F5xx_6xx_Grlib_Example.ewp</path>
  </project>
  <batchBuild/>
</workspace>


