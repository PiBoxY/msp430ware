<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MSP-EXP430FR5969_Grlib_Example_Sharp128.ewp</path>
  </project>
  <batchBuild/>
</workspace>


