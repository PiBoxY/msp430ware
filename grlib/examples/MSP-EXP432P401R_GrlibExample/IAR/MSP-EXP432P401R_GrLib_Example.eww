<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MSP-EXP432P401R_GrLib_Example.ewp</path>
  </project>
  <batchBuild/>
</workspace>


